## app/boards/our_board/board.yml
```yaml
board:
  name: our_board
  full_name: Our Board
  vendor: Custom Vendor
  socs:
  - name: esp32
```
